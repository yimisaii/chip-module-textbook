# Keil uVision project GPIO_EXTI.uvprojx, settings and files
target GPIO_EXTI (ARM-ADS)
  device: STM32U575ZITxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x00030000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(4000000) ELITTLE
  output: GPIO_EXTI +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32U575xx
  c misc: -std=c99
  c include: ..\Core;..\Drivers\STM32U5xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32U5xx\Include
  scatter file: .\GPIO_EXTI.sct
  group Application
    ../Core/: main.c button.c
  group CMSIS Startup
    ../Drivers/CMSIS/Device/ST/STM32U5xx/Source/Templates/arm/: startup_stm32u575xx.s
    ../Drivers/CMSIS/Device/ST/STM32U5xx/Source/Templates/: system_stm32u5xx.c
  group STM32U5 HAL1
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_rcc.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c
